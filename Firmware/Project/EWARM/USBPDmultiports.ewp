# IAR project USBPDmultiports.ewp, settings and files
configuration USBPDmultiports (ARM, debug)
  General.OGChipSelectEditMenu: STM32F072CB ST STM32F072CB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F072xB; CONSOLE_PRINTF; DEBUG_PRINTF; HW_NUCLEO_2PORTS
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32F0xx_HAL_Driver/Inc; ../Drivers/STM32F0xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F0xx/Include; ../Drivers/CMSIS/Include; ..\Src; ..\Src\USBPD_Lib
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: USBPDmultiports.bin
  ILINK.IlinkOutputFile: USBPDmultiports.out
  ILINK.IlinkIcfFile: stm32f072xb_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f072xb.s
  group Application/USBPD_Lib
    ../Src/USBPD_Lib/: USB_PD_core.c USB_PD_user.c
  group Application/User
    ../Src/: gpio_hardware_test.c gpio_i2c_pullup.c GPIO_Interrupt_callback.c I2C_ReadWrite.c main.c main_process.c PostProcessEvents.c printf_retarget.c stm32f0xx_hal_msp.c stm32f0xx_it.c STUSB4700_USBPD_functions.c timer_process.c UART_process.c utils.c
  group Drivers/CMSIS
    ../Src/: system_stm32f0xx.c
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal.c stm32f0xx_hal_cortex.c stm32f0xx_hal_dma.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_i2c.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_spi.c stm32f0xx_hal_spi_ex.c stm32f0xx_hal_tim.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_uart.c stm32f0xx_hal_uart_ex.c
